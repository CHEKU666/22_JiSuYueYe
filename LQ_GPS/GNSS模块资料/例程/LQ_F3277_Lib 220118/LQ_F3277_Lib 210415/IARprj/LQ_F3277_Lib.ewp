# IAR project LQ_F3277_Lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; USE_IAR
  ICCARM.CCIncludePath2: ..\Device\MM32F3277\HAL_Lib\Inc; ..\Device\MM32F3277\HAL_Lib\Src; ..\Device\MM32F3277\Include; ..\Device\MM32F3277\Source; ..\Device\CMSIS\IAR_Core; ..\UER; ..\APP; ..\Device\MM32F3277\HAL_Lib\Inc; ..\Device\MM32F3277\HAL_Lib\Src; ..\Device\MM32F3277\Include; ..\Device\MM32F3277\Source; ..\Device\CMSIS\IAR_Core; ..\UER; ..\APP; ..\DRV; ..\APP\ICM20602; ..\APP\ICM42605; ..\APP\LQ9AX; ..\APP\MPU6050; ..\APP\MPU9250; ..\APP\ICM20689; ..\APP\GPS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIM_PWM.srec
  ILINK.IlinkOutputFile: MM32.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\MindMotion\MM32F3270.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\Device\MM32F3277\HAL_Lib\Inc; ..\Device\MM32F3277\HAL_Lib\Src; ..\Device\MM32F3277\Include; ..\Device\MM32F3277\Source; ..\Device\CMSIS\IAR_Core; ..\UER; ..\APP; ..\Device\MM32F3277\HAL_Lib\Inc; ..\Device\MM32F3277\HAL_Lib\Src; ..\Device\MM32F3277\Include; ..\Device\MM32F3277\Source; ..\Device\CMSIS\IAR_Core; ..\UER; ..\APP; ..\DRV; ..\APP\ICM20602; ..\APP\ICM42605; ..\APP\LQ9AX; ..\APP\MPU6050; ..\APP\MPU9250; ..\APP\ICM20689
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: LQ_SPIN2x_Lib.out
  group App
    ../APP/: include.h LQ_AAConfig.h LQ_AnoScope.c LQ_CAMERA.c LQ_CAMERA.h LQ_GPIO_EXIT.c LQ_GPIO_EXIT.h LQ_GPIO_KEY.c LQ_GPIO_KEY.h LQ_GPIO_LED.c LQ_GPIO_LED.h LQ_ImageProcess.c LQ_ImageProcess.h LQ_Inductor.c LQ_Inductor.h LQ_MotorServo.c LQ_MotorServo.h LQ_MT9V034.c LQ_MT9V034.h LQ_OLED096.c LQ_OLED096.h LQ_PID.c LQ_PID.h LQ_TFT18.c LQ_TFT18.h LQ_TFT18Pic.h 用户可以在此文件夹添加自己的文件.txt
  group App/GNSS
    ../APP/GPS/: Algorithm.c Algorithm.h LQ_GPS_BD.c LQ_GPS_BD.h
  group App/ICM20689
    ../APP/: LQ_ICM20689.c LQ_ICM20689.h
  group App/MPU6050
    ../APP/MPU6050/: LQ_demo_DMP.c LQ_I2C_MPU6050.c LQ_I2C_MPU6050.h LQ_MPU6050_DMP.a LQ_MPU6050_DMP.h
  group App/MPU9250
    ../APP/MPU9250/: LQ_I2C_MPU9250.c LQ_I2C_MPU9250.h
  group DRV
    ../DRV/: LQ_ADC.c LQ_ADC.h LQ_DMA.c LQ_DMA.h LQ_Encoder.c LQ_Encoder.h LQ_FLASH.c LQ_FLASH.h LQ_GPIO.c LQ_GPIO.h LQ_I2C.c LQ_I2C.h LQ_PWM.c LQ_PWM.h LQ_SOFTI2C.c LQ_SOFTI2C.h LQ_SOFTSPI.c LQ_SOFTSPI.h LQ_SPI.c LQ_SPI.h LQ_SYS.c LQ_SYS.h LQ_TIMER.c LQ_TIMER.h LQ_UART.c LQ_UART.h
  group HALlib
    ../Device/MM32F3277/HAL_Lib/Inc/: dtype.h hal_adc.h hal_bkp.h hal_can.h hal_comp.h hal_conf.h hal_crc.h hal_crs.h hal_dac.h hal_dbg.h hal_device.h hal_dma.h hal_eth.h hal_eth_conf.h hal_exti.h hal_flash.h hal_fsmc.h hal_gpio.h hal_i2c.h hal_iwdg.h hal_misc.h hal_pwr.h hal_rcc.h hal_redefine.h hal_rtc.h hal_sdio.h hal_spi.h hal_syscfg.h hal_tim.h hal_uart.h hal_uid.h hal_ver.h hal_wwdg.h
    ../Device/MM32F3277/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../Device/MM32F3277/Source/IAR_StartAsm/: startup_mm32f327x_iar.s
    ../Device/MM32F3277/Source/: system_mm32f327x.c
  group USER
    ../USER/: main.c 龙邱ARM144p母板资源分配.txt
